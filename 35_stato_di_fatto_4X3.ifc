Properties of the parts of a building model (IFC4X3_ADD2)

# File
Time: 2024-12-11T11:26:18
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcBuilding, Terreno
Description: Created by Civil Site Design

# IfcBuildingElementProxy, Terreno
In: Terreno
Description: Created by Civil Site Design
