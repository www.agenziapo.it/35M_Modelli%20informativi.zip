Properties of the parts of a building model (IFC4X3_ADD2)

# File
File name: 35_stato_di_progetto_4X3.ifc
Time: 2025-02-13T16:57:27+01:00
Written by: IfcOpenShell 0.8.2-alpha250212
Made in: Bonsai 0.8.2-alpha250212-f24de9d

# IfcBuildingElementProxy (21)
Description: Created by Civil Site Design
Name | In | String Name | Code 1 | Code 2 | Layer Index | Material
asse_corpo/C.L./RST/3/CP - Pietrame 300-1000 kg | Corpo pennello | asse_corpo | C.L. | RST | 3 | CP - Pietrame 300-1000 kg
asse_corpo/RST/RAT/1/CP - Pietrame 300-1000 kg | Corpo pennello | asse_corpo | RST | RAT | 1 | CP - Pietrame 300-1000 kg
asse_corpo/LAT/LAFS/1/CP - Pietrame 300-1000 kg | Corpo pennello | asse_corpo | LAT | LAFS | 1 | CP - Pietrame 300-1000 kg
asse_corpo/LAFS/LAFR/1/CP - Pietrame 300-1000 kg | Corpo pennello | asse_corpo | LAFS | LAFR | 1 | CP - Pietrame 300-1000 kg
asse_corpo/RAB/RAD/1/TA - Pietrame 300-1000 kg | Corpo pennello | asse_corpo | RAB | RAD | 1 | TA - Pietrame 300-1000 kg
asse_piede/L2/L3/1/PP - Tappeti zavorrati | Piede pennello | asse_piede | L2 | L3 | 1 | PP - Tappeti zavorrati
asse_piede/L1/L2/2/PP - Burghe | Piede pennello | asse_piede | L1 | L2 | 2 | PP - Burghe
asse_corpo/RAT/RAD/1/CP - Pietrame 300-1000 kg | Corpo pennello | asse_corpo | RAT | RAD | 1 | CP - Pietrame 300-1000 kg
asse_piede/L1/L2/3/PP - Pietrame 300-1000 kg | Piede pennello | asse_piede | L1 | L2 | 3 | PP - Pietrame 300-1000 kg
asse_piede/L1/L2/1/PP - Tappeti zavorrati | Piede pennello | asse_piede | L1 | L2 | 1 | PP - Tappeti zavorrati
asse_piede/L2/L3/2/PP - Burghe | Piede pennello | asse_piede | L2 | L3 | 2 | PP - Burghe
asse_piede/C.L./L1/1/PP - Burghe | Piede pennello | asse_piede | C.L. | L1 | 1 | PP - Burghe
asse_piede/C.L./L1/2/PP - Pietrame 300-1000 kg | Piede pennello | asse_piede | C.L. | L1 | 2 | PP - Pietrame 300-1000 kg
Terreno | Lanca
asse_corpo/LST/LAT/1/CP - Pietrame 300-1000 kg | Corpo pennello | asse_corpo | LST | LAT | 1 | CP - Pietrame 300-1000 kg
asse_corpo/C.L./LST/1/ST - Misto stabilizzato | Strada | asse_corpo | C.L. | LST | 1 | ST - Misto stabilizzato
asse_corpo/C.L./LST/2/ST - Tout Venant | Strada | asse_corpo | C.L. | LST | 2 | ST - Tout Venant
asse_corpo/C.L./LST/3/CP - Pietrame 300-1000 kg | Corpo pennello | asse_corpo | C.L. | LST | 3 | CP - Pietrame 300-1000 kg
asse_corpo/C.L./RST/1/ST - Misto stabilizzato | Strada | asse_corpo | C.L. | RST | 1 | ST - Misto stabilizzato
asse_corpo/C.L./RST/2/ST - Tout Venant | Strada | asse_corpo | C.L. | RST | 2 | ST - Tout Venant
asse_piede/L3/L4/1/PP - Tappeti zavorrati | Piede pennello | asse_piede | L3 | L4 | 1 | PP - Tappeti zavorrati
